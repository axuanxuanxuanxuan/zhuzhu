# Keil uVision project fen48dengcongming.uvproj, settings and files
target 目标 1 (MCS-51)
  device: STC15F104W STC
  cpu: IRAM(0-0x7F) IROM(0-0xFF8) CLOCK(35000000)
  output: fen48dengcongming +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: STARTUP.A51 fen48dengcongming.c
